# Keil uVision project BEEP.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BEEP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\TIME;..\USER;..\HARDWARE;..\HARDWARE\USART;..\HARDWARE\OLED;..\HARDWARE\DHT11;..\HARDWARE\AD;..\STM32F10x_FWLib\src;..\HARDWARE\BLUETOOTH;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/AD/: ad.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
software components: CMSIS:CORE 5.4.0
